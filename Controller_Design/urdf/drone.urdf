Commit message: Figuring out annoying issues with simulation

File: Controller_Design/urdf/drone.urdf (robot description, URDF)
Before this commit: robot drone, 7 links, 6 joints
Joints:
- joint base_to_bar: limit velocity=1000 -> (none)
